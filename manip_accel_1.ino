// Joint speeds are in degrees per second
#include <Arduino.h>
#include <math.h>
#include <stdlib.h>
#include <ctype.h>
#include <string.h>
#include <avr/interrupt.h>
#include <util/atomic.h>
// Store the smooth quick-stop curve in flash, not SRAM.
#include <avr/pgmspace.h>
#if !defined(__AVR_ATmega2560__) || F_CPU != 16000000UL
#error "This sketch requires an Arduino Mega 2560 at 16 MHz."
#endif

const byte NM = 6;
const byte NJ = 5;

// Includes driver microstepping.
const double PULSES_PER_REV[NM] = {
  1600, 1600, 1600, 1600, 1600, 1600
};

// Motor revolutions per joint revolution.
const double GEAR[NJ] = {10, 5, 20, 1, 4};

const byte STEP_PIN[NM] = {2, 4, 6, 8, 10, 12};
const byte DIR_PIN[NM]  = {3, 5, 7, 9, 11, 13};
const byte EN_PIN[NM]   = {23, 25, 27, 29, 31, 33};

const byte JOINT[NM] = {0, 1, 1, 2, 3, 4};
const byte PRIMARY[NJ] = {0, 1, 3, 4, 5};

// J2 motors rotate in opposite directions.
const bool POS_DIR[NM] = {
  true, true, false, true, true, true
};

const bool LIMITED[NJ] = {true, true, true, true, true};
const double MIN_DEG[NJ] = {-70, -90, -90, -180, -90};
const double MAX_DEG[NJ] = {170,  90,  90,   90,  90};

const byte ENABLE = LOW;
const byte DISABLE = HIGH;

// Full-speed normal ramps last 0.5 s; quick stops last up to 0.1 s.
const double RAMP_SECONDS = 0.5;
const uint32_t QUICK_STOP_TICKS = 200000UL;
const double MAX_STEP_HZ = 2000.0;
const double MAX_JOINT_DPS = 22.5;
const unsigned long STEP_HIGH_US = 20;
const unsigned long STEP_LOW_US = 20;
const long MAX_MOVE_PULSES = 1000000L;
const double MAX_POSITION_PULSES = 16000000.0;

volatile long position[NM] = {0};
volatile unsigned long count[NM] = {0};
int stepSign[NM] = {0};
bool homed[NJ] = {false};

double speedDps[NJ] = {10.0, 10.0, 10.0, 10.0, 10.0};
unsigned long periodUs[NJ] = {0};
// Shared motion flags are accessed by Timer1 and the main loop.
volatile bool pulseHigh[NJ] = {false};
volatile bool moving = false;
bool configOK = false;
// -2: no request; -1: all joints; 0..4: one joint.
int pendingDisable = -2;
bool positionReportPending = false;

byte selected = 0;

char buffer[160];
unsigned int bufferLength = 0;
bool overflowed = false;

// Timer1 runs at 2 MHz (0.5 us/tick) in normal mode.
// It is reserved exclusively for motion; do not use Timer1 PWM or libraries.
// STEP mapping is fixed to the Mega 2560 pins in STEP_PIN above.
volatile uint32_t riseWait[NJ] = {0};
volatile uint32_t fallWait[NJ] = {0};
// explicitly enforce the minimum LOW time after every falling edge.
volatile uint32_t lowWait[NJ] = {0};
uint32_t periodTicks[NJ] = {0};
volatile uint16_t timerReference = 0;
volatile bool motionFinished = false;
volatile bool timingFault = false;

// Profile planner forward declaration.
double pulsesPerDegree(byte m);
// Precompute only the ramp intervals while stopped. The ISR
// mirrors them for deceleration, using integer lookups and no square roots.
// 1100 entries cover all five joints at 22.5 deg/s with the configured gearing.
const uint16_t RAMP_CAPACITY = 1100;
uint32_t rampTicks[RAMP_CAPACITY];
uint16_t rampOffset[NJ] = {0};
uint16_t rampLength[NJ] = {0};
uint32_t moveSteps[NJ] = {0};
uint32_t cruiseTicks[NJ] = {0};

uint32_t intervalForStep(byte j, uint32_t k) {
  uint32_t mirror = moveSteps[j] + 1UL - k;
  uint32_t index = k < mirror ? k : mirror;
  if (index <= rampLength[j]) return rampTicks[rampOffset[j] + index - 1UL];
  return cruiseTicks[j];
}

// Exact constant-acceleration crossing times in step space.
// Short moves use a triangular profile; long moves include a cruise segment.
// Rounding uses the actual whole-step endpoint, so no steps are added/lost.
bool prepareRamps(const long delta[NM]) {
  uint16_t used = 0;
  for (byte j = 0; j < NJ; j++) {
    uint32_t n = (uint32_t)labs(delta[PRIMARY[j]]);
    moveSteps[j] = n;
    rampLength[j] = 0;
    if (!n) continue;
    double scale = pulsesPerDegree(PRIMARY[j]);
    double accel = speedDps[j] * scale / RAMP_SECONDS;
    double velocity = (speedDps[j] * PULSES_PER_REV[PRIMARY[j]] * GEAR[j]) / 360.0;
    double accelSteps = velocity * velocity / (2.0 * accel);
    if (accelSteps > n / 2.0) accelSteps = n / 2.0;
    double peak = sqrt(2.0 * accel * accelSteps);
    double rampTime = peak / accel;
    double totalTime = 2.0 * rampTime + (n - 2.0 * accelSteps) / velocity;
    uint16_t length = (uint16_t)ceil(accelSteps);
    if ((uint32_t)used + length > RAMP_CAPACITY) {
      Serial.println(F("Ramp buffer exceeded; check acceleration/gearing."));
      return false;
    }
    rampOffset[j] = used;
    rampLength[j] = length;
    cruiseTicks[j] = (uint32_t)ceil(2000000.0 / velocity);
    double previous = 0;
    for (uint16_t k = 1; k <= length; k++) {
      double time;
      if (2UL * k > n) {
        // The middle interval of an odd triangular move spans
        // the acceleration/deceleration transition and must not be doubled.
        time = totalTime - previous;
      } else if (k <= accelSteps) time = sqrt(2.0 * k / accel);
      else time = rampTime + (k - accelSteps) / velocity;
      double ticks = ceil((time - previous) * 2000000.0);
      if (!isfinite(ticks) || ticks < 80.0 || ticks > 4000000000.0) {
        Serial.println(F("Ramp interval out of range."));
        return false;
      }
      rampTicks[used++] = (uint32_t)ticks;
      previous = time;
    }
  }
  return true;
}

// Inverse integrated smoothstep velocity: v(u)=v0*(1-3u^2+2u^3).
// Its acceleration starts and ends at zero. Precomputed intervals for 1..100
// braking steps avoid divisions in the ISR. Repeated S does not restart braking.
const uint16_t stopCurve[5050] PROGMEM = {
65535,17458,48078,11224,13465,40847,8317,9141,11539,36539,6618,7018,7992,10336,33572,5498,
5726,6234,7231,9490,31357,4705,4845,5150,5692,6679,8850,29615,4112,4205,4404,4737,
5286,6253,8344,28195,3652,3718,3854,4076,4422,4967,5911,7930,27006,3285,3333,3431,
3587,3822,4170,4708,5628,7583,25989,2985,3021,3094,3209,3377,3615,3962,4492,5389,
7285,25107,2735,2763,2819,2907,3030,3204,3444,3787,4308,5182,7027,24330,2524,2546,
2590,2658,2753,2883,3058,3298,3638,4148,5002,6800,23638,2344,2361,2396,2449,2525,
2625,2758,2934,3172,3507,4007,4843,6598,23017,2187,2201,2230,2273,2333,2412,2516,
2650,2826,3061,3392,3883,4701,6416,22455,2050,2062,2085,2120,2170,2234,2316,2421,
2555,2731,2964,3289,3771,4573,6253,21942,1929,1939,1959,1988,2028,2081,2148,2232,
2338,2472,2646,2876,3197,3670,4457,6103,21473,1822,1830,1846,1872,1905,1949,2004,
2072,2158,2264,2397,2570,2798,3113,3579,4351,5966,21040,1726,1733,1746,1768,1797,
1833,1879,1936,2006,2091,2198,2331,2501,2726,3037,3495,4254,5840,20639,1639,1646,
1657,1676,1699,1732,1769,1818,1876,1946,2032,2138,2269,2439,2661,2967,3418,4165,
5723,20266,1561,1567,1577,1592,1613,1640,1674,1713,1763,1821,1893,1978,2083,2214,
2382,2600,2903,3347,4082,5614,19919,1490,1495,1504,1517,1535,1559,1587,1622,1664,
1713,1772,1843,1929,2033,2164,2328,2546,2843,3281,4004,5514,19593,1425,1430,1437,
1449,1465,1485,1510,1540,1575,1618,1668,1728,1798,1884,1988,2116,2280,2494,2787,
3220,3933,5419,19287,1366,1369,1377,1386,1401,1418,1441,1466,1497,1533,1577,1627,
1686,1758,1842,1945,2073,2235,2446,2736,3162,3865,5331,18999,1311,1315,1320,1330,
1342,1357,1377,1399,1427,1458,1495,1539,1589,1649,1720,1803,1906,2033,2192,2402,
2687,3109,3802,5247,18727,1261,1263,1269,1277,1288,1302,1319,1339,1363,1390,1423,
1460,1504,1554,1614,1684,1768,1870,1995,2153,2359,2643,3057,3743,5168,18470,1214,
1217,1221,1229,1238,1251,1265,1284,1305,1329,1357,1390,1428,1471,1523,1581,1652,
1734,1836,1959,2116,2320,2600,3010,3686,5094,18226,1171,1173,1177,1184,1192,1204,
1216,1233,1252,1273,1298,1327,1360,1398,1441,1493,1551,1621,1703,1804,1926,2081,
2283,2560,2965,3633,5023,17994,1130,1133,1136,1142,1150,1160,1171,1186,1203,1222,
1245,1269,1299,1332,1370,1414,1464,1523,1592,1674,1774,1894,2049,2248,2522,2922,
3583,4956,17773,1093,1094,1098,1103,1110,1120,1130,1143,1158,1175,1195,1217,1243,
1273,1306,1344,1387,1439,1496,1565,1647,1745,1865,2018,2215,2486,2882,3534,4892,
17563,1057,1059,1062,1067,1074,1081,1092,1102,1117,1132,1149,1170,1193,1218,1248,
1282,1320,1363,1413,1472,1540,1621,1718,1837,1988,2184,2452,2843,3489,4832,17361,
1024,1026,1029,1033,1039,1046,1055,1065,1078,1092,1108,1126,1146,1170,1196,1225,
1259,1296,1341,1390,1448,1516,1596,1693,1811,1960,2154,2419,2807,3446,4773,17169,
993,995,997,1001,1007,1013,1021,1031,1042,1055,1069,1085,1104,1125,1148,1174,
1204,1237,1275,1319,1368,1426,1494,1572,1669,1786,1934,2125,2388,2772,3404,4718,
16985,964,965,968,971,976,983,989,999,1008,1020,1033,1048,1065,1083,1104,
1128,1154,1184,1217,1255,1298,1348,1405,1471,1551,1646,1762,1908,2099,2358,2739,
3364,4665,16808,936,938,940,943,948,953,960,968,977,987,1000,1013,1028,
1045,1064,1085,1109,1135,1165,1198,1236,1278,1328,1385,1452,1529,1624,1740,1884,
2073,2330,2707,3326,4614,16638,910,912,913,917,921,925,932,940,947,958,
968,981,994,1010,1026,1046,1067,1091,1117,1147,1180,1217,1261,1309,1366,1432,
1510,1603,1718,1861,2048,2303,2676,3290,4565,16475,886,887,888,892,895,900,
906,912,920,929,939,950,963,977,992,1009,1029,1050,1074,1100,1130,1163,
1200,1243,1292,1348,1413,1490,1584,1697,1839,2025,2277,2647,3254,4519,16317,862,
864,865,868,871,875,881,887,894,903,911,922,933,946,960,976,993,
1013,1034,1057,1084,1114,1147,1184,1226,1275,1330,1396,1472,1565,1677,1818,2002,
2252,2619,3221,4473,16166,840,842,842,845,849,852,858,863,869,878,885,
895,906,917,930,945,960,978,997,1019,1042,1069,1098,1131,1169,1210,1259,
1314,1379,1455,1546,1658,1798,1980,2228,2592,3189,4429,16020,819,820,822,824,
827,830,835,841,846,853,862,870,879,890,903,915,930,946,963,983,
1004,1028,1054,1084,1116,1153,1196,1243,1298,1363,1438,1529,1639,1779,1959,2206,
2565,3158,4387,15879,799,800,802,803,807,809,814,819,825,831,838,846,
855,865,876,888,902,915,932,950,969,990,1014,1041,1069,1102,1140,1180,
1229,1283,1347,1422,1512,1622,1760,1939,2184,2540,3127,4348,15742,780,781,783,
784,787,790,793,799,804,809,817,823,832,842,851,862,875,888,903,
918,937,956,977,1001,1027,1056,1089,1125,1167,1215,1268,1332,1407,1496,1605,
1742,1920,2162,2516,3098,4309,15610,762,763,764,766,768,771,775,779,784,
789,796,803,810,819,828,838,850,862,875,890,906,924,943,965,988,
1015,1043,1076,1112,1154,1201,1255,1317,1392,1480,1589,1725,1901,2142,2492,3071,
4270,15483,745,745,747,748,750,754,756,761,765,770,776,783,790,797,
806,816,826,838,849,864,878,894,912,931,953,976,1002,1031,1064,1100,
1141,1187,1242,1304,1377,1466,1573,1708,1883,2121,2471,3043,4234,15359,728,729,
730,731,734,736,739,743,748,752,757,764,770,777,786,794,804,814,
826,838,852,867,882,901,920,941,965,990,1020,1051,1088,1129,1175,1228,
1291,1364,1451,1558,1692,1865,2103,2448,3017,4199,15239,712,713,714,716,717,
720,723,726,730,735,740,745,751,759,766,774,783,792,803,815,827,
841,856,872,889,909,930,954,979,1009,1040,1076,1117,1163,1216,1278,1350,
1437,1544,1676,1849,2084,2427,2992,4164,15123,697,698,699,700,702,704,707,
710,714,718,723,728,734,740,747,755,763,772,782,793,804,817,830,
845,862,879,898,920,943,969,997,1029,1065,1106,1151,1204,1266,1337,1424,
1529,1661,1833,2066,2407,2967,4131,15010,683,683,684,685,687,690,692,694,
699,702,707,711,718,723,729,737,744,753,762,771,783,794,806,821,
835,851,869,889,909,933,958,987,1019,1054,1095,1140,1192,1254,1325,1411,
1515,1647,1817,2048,2388,2943,4099,14900,669,669,670,671,673,675,678,680,
683,687,692,696,701,706,713,719,727,734,743,752,762,773,784,797,
811,826,841,860,878,900,923,948,977,1009,1044,1083,1130,1181,1242,1313,
1399,1502,1632,1802,2032,2368,2920,4067,14794,655,656,657,658,659,661,664,
666,669,673,676,681,686,691,697,702,710,717,725,733,743,752,764,
775,788,801,817,832,850,870,890,913,939,967,999,1034,1073,1119,1171,
1231,1301,1386,1490,1619,1787,2015,2349,2898,4037,14690,643,643,643,645,646,
648,650,653,656,658,663,667,671,676,681,687,694,700,708,715,725,
733,744,755,766,779,793,807,824,841,860,881,905,929,958,989,1024,
1064,1109,1160,1220,1290,1375,1477,1605,1773,1999,2331,2876,4008,14589,630,631,
631,632,634,635,638,639,643,645,650,652,657,662,667,672,678,685,
691,699,707,716,725,735,746,758,770,784,799,815,833,851,873,895,
921,949,980,1015,1054,1099,1150,1209,1280,1363,1465,1592,1759,1984,2313,2855,
3979,14491,618,619,619,621,621,623,625,628,630,632,637,639,644,648,
653,658,663,670,676,683,690,699,707,717,727,738,749,762,776,791,
807,824,843,864,887,912,940,971,1006,1045,1089,1140,1200,1269,1352,1453,
1580,1745,1969,2297,2834,3951,14395,607,607,608,609,609,612,613,616,617,
621,624,627,631,634,640,644,650,655,661,668,675,682,691,699,709,
719,730,741,755,768,782,799,816,836,856,878,904,932,962,997,1036,
1080,1131,1189,1259,1341,1442,1568,1732,1954,2280,2814,3924,14302,596,596,597,
597,599,600,602,604,606,609,612,615,618,622,627,631,636,642,647,
653,660,667,675,683,692,701,711,722,734,747,760,775,792,808,827,
848,871,896,923,954,989,1027,1071,1122,1180,1248,1331,1431,1556,1719,1941,
2263,2794,3898,14211,585,586,586,587,587,590,591,593,595,597,600,604,
606,610,615,618,624,628,634,639,646,652,660,667,676,684,694,704,
715,726,740,753,767,784,801,820,840,863,888,916,946,980,1018,1063,
1112,1171,1239,1321,1420,1545,1707,1926,2248,2775,3872,14122,575,575,576,576,
578,579,580,582,584,587,589,592,596,598,603,606,611,616,621,626,
632,639,645,652,660,669,677,687,697,707,720,732,746,761,776,794,
812,833,856,880,908,938,972,1011,1054,1104,1161,1230,1311,1410,1533,1695,
1913,2232,2757,3846,14036,565,565,566,567,567,569,570,572,574,576,578,
582,584,587,591,595,600,603,609,613,620,625,631,638,646,653,662,
670,680,690,701,713,725,739,753,770,787,805,826,848,873,901,930,
964,1003,1046,1095,1153,1221,1301,1399,1523,1683,1900,2217,2739,3822,13951,555,
556,556,557,558,559,560,562,564,566,568,571,574,577,580,584,588,
592,596,602,606,613,618,625,631,639,647,655,663,674,683,695,706,
718,733,746,763,780,799,819,841,866,893,923,957,995,1037,1088,1144,
1212,1291,1390,1512,1671,1888,2202,2721,3798,13869,546,547,546,548,548,550,
551,552,554,556,559,561,563,567,569,574,577,581,585,590,594,601,
605,612,618,625,633,640,648,658,667,677,688,699,713,726,740,756,
773,792,813,834,859,886,916,949,988,1030,1079,1136,1203,1283,1380,1502,
1659,1875,2189,2703,3775,13788,537,538,538,538,539,541,541,544,544,547,
549,551,554,556,560,563,566,571,574,579,583,589,593,600,605,612,
619,626,634,642,652,660,671,682,693,706,720,734,750,767,785,806,
828,852,879,909,942,980,1023,1071,1128,1195,1274,1370,1492,1649,1863,2174,
2687,3752,13709,529,528,529,530,531,531,533,534,536,538,539,542,545,
547,549,553,557,560,564,568,572,577,582,588,593,600,606,612,621,
627,637,645,655,665,676,687,700,713,728,744,761,779,799,822,845,
873,902,935,973,1015,1064,1120,1186,1266,1361,1482,1638,1851,2161,2671,3729,
13632,520,521,520,522,522,523,524,525,528,528,531,533,535,538,540,
544,546,550,554,558,562,566,571,576,582,588,593,600,607,614,623,
630,640,649,659,670,681,694,708,722,738,754,773,794,815,839,866,
895,929,966,1008,1056,1113,1178,1257,1352,1473,1628,1839,2147,2655,3707,13557,
512,512,513,513,514,515,516,517,518,521,522,524,526,529,531,534,
538,540,544,548,552,556,560,566,570,576,582,588,594,602,608,617,
625,634,643,653,665,676,688,702,716,732,749,767,787,809,833,860,
889,922,959,1001,1049,1105,1171,1248,1344,1463,1618,1828,2134,2639,3686,13483,
504,504,505,505,506,507,508,509,510,512,514,516,518,520,522,526,
528,531,535,538,542,546,550,555,560,565,571,576,582,589,596,603,
611,620,628,638,648,659,671,682,697,710,727,743,761,781,803,827,
854,883,915,953,994,1042,1098,1162,1241,1335,1454,1608,1817,2122,2623,3665,
13411,497,496,497,498,498,499,500,501,503,504,505,508,510,511,514,
517,520,522,526,529,532,537,540,545,550,554,560,565,570,578,583,
591,598,606,614,623,633,642,654,665,678,690,706,720,738,756,775,
797,822,847,877,909,946,988,1035,1090,1156,1232,1327,1445,1598,1806,2110,
2608,3645,13340,489,489,490,490,491,491,493,493,495,496,498,500,501,
504,506,508,511,514,517,520,524,527,531,535,540,544,549,555,560,
565,572,579,585,593,601,609,618,628,637,648,660,673,685,700,716,
732,750,770,792,815,842,870,903,940,981,1029,1083,1148,1225,1319,1437,
1588,1795,2098,2594,3624,13271,482,482,482,483,484,484,485,486,488,488,
491,492,493,496,498,501,502,506,508,512,515,518,522,526,530,535,
539,544,549,555,561,567,573,581,588,596,604,613,622,633,643,655,
667,681,694,711,726,745,765,786,810,836,865,897,933,975,1022,1077,
1141,1217,1311,1428,1579,1785,2086,2579,3605,13203,475,475,475,476,477,477,
478,479,480,481,483,485,486,488,491,492,495,498,500,503,507,509,
514,517,521,525,529,534,540,544,550,556,562,569,576,583,591,599,
608,618,627,639,650,662,676,689,705,722,740,759,781,804,831,859,
891,928,968,1016,1070,1134,1210,1303,1420,1570,1775,2074,2565,3586,13136,468,
468,469,469,470,470,471,472,473,475,475,478,479,481,483,485,487,
490,492,495,499,501,505,508,512,516,520,525,530,534,540,545,551,
558,564,571,578,587,594,604,613,623,633,645,658,670,685,700,717,
735,754,775,799,825,854,886,921,963,1009,1064,1127,1203,1296,1411,1561,
1765,2063,2551,3567,13071,462,461,462,463,462,464,464,466,466,468,469,
470,472,474,475,478,480,482,485,488,490,493,497,500,503,508,511,
516,520,525,529,536,540,547,553,559,567,574,581,591,598,609,618,
629,641,652,666,680,696,711,730,749,771,793,820,848,880,916,957,
1003,1058,1120,1196,1288,1403,1553,1755,2052,2538,3548,13007,455,455,456,456,
456,457,458,459,460,461,462,463,466,466,469,471,472,475,478,480,
483,485,489,492,495,499,503,507,511,515,521,525,531,536,542,549,
555,562,569,578,585,595,604,613,625,636,648,661,676,690,707,725,
744,766,789,814,843,875,910,951,997,1051,1114,1189,1281,1395,1544,1746,
2041,2524,3531,12944,449,449,449,450,450,451,451,453,453,454,456,457,
459,460,462,463,466,468,470,473,475,478,481,485,487,491,494,499,
502,507,511,516,521,527,532,538,544,550,558,565,573,582,590,599,
610,620,631,644,657,671,686,702,720,739,761,784,809,838,869,905,
945,992,1045,1107,1183,1273,1388,1536,1736,2030,2512,3512,12883,443,443,443,
444,444,444,445,447,447,448,449,451,452,454,455,457,459,461,463,
466,468,471,474,476,480,483,486,491,494,498,502,507,512,517,522,
528,534,540,546,554,561,569,577,586,595,605,616,627,639,653,666,
682,697,716,735,755,779,805,832,865,899,940,986,1039,1101,1176,1266,
1381,1527,1727,2020,2499,3495,12822,437,437,437,438,438,439,439,440,441,
442,443,445,445,448,449,450,453,454,457,459,461,464,466,469,473,
475,479,482,486,490,494,499,502,508,513,518,524,529,536,543,549,
557,565,573,582,591,601,611,623,635,648,662,678,693,711,730,751,
774,800,828,859,894,934,980,1034,1095,1169,1260,1373,1519,1719,2009,2486,
3478,12763,431,431,432,432,432,433,433,435,435,436,437,438,440,441,
443,444,446,448,450,453,454,457,460,462,465,468,471,475,478,482,
486,490,494,499,504,509,514,520,526,531,539,545,553,561,569,578,
587,597,607,619,631,644,658,672,689,707,726,746,770,795,823,854,
889,929,975,1027,1089,1163,1253,1366,1511,1710,1999,2474,3461,12705,426,425,
426,426,427,427,428,428,430,430,432,432,434,435,437,438,440,442,
443,446,448,450,453,455,459,461,464,467,471,474,478,482,486,491,
495,499,505,511,515,522,528,535,542,549,556,565,574,583,593,604,
615,627,639,654,669,684,703,721,742,765,790,818,850,884,924,969,
1022,1083,1157,1246,1359,1504,1701,1989,2462,3445,12647,420,420,421,421,421,
421,423,422,424,425,426,426,428,430,430,433,434,435,438,440,441,
444,446,449,451,455,457,460,463,467,471,474,478,482,487,491,496,
501,507,512,518,524,531,538,545,553,561,570,580,589,599,611,623,
636,650,664,681,698,717,738,760,786,813,845,879,919,964,1016,1077,
1151,1240,1352,1496,1693,1979,2450,3429,12591,415,415,415,415,416,416,417,
418,418,419,420,422,422,424,425,426,428,430,432,433,436,437,440,
442,445,448,450,453,457,460,463,466,471,474,479,483,487,493,497,
503,508,515,520,528,534,541,550,557,566,576,585,596,607,619,632,
645,661,676,694,713,734,756,781,809,840,874,914,959,1011,1072,1145,
1233,1345,1489,1684,1970,2439,3412,12536,410,409,410,410,411,411,412,412,
413,414,414,416,417,418,420,421,422,424,426,427,430,432,433,437,
438,441,444,446,450,453,456,459,463,467,471,475,479,484,489,494,
499,505,511,517,523,531,538,546,553,563,572,581,593,603,615,628,
642,656,673,690,709,729,752,777,804,835,870,909,954,1005,1067,1139,
1227,1338,1482,1676,1960,2427,3398,12481,405,404,405,405,406,406,406,407,
408,409,409,411,411,413,414,415,417,419,420,422,423,426,428,430,
432,435,438,440,443,446,449,452,456,460,463,467,472,475,481,485,
491,495,502,507,514,520,527,534,542,551,559,568,578,588,600,611,
625,638,652,669,686,705,725,748,772,800,831,865,904,949,1000,1061,
1134,1221,1331,1475,1668,1951,2416,3382,12428,400,399,400,400,401,401,401,
402,403,404,404,405,407,407,409,410,412,413,414,417,418,420,422,
424,426,429,431,434,437,439,443,445,449,453,456,459,464,468,473,
477,482,487,492,498,504,510,517,524,530,539,547,555,565,575,584,
596,608,621,634,649,665,682,701,721,744,768,796,826,861,899,944,
995,1056,1128,1215,1325,1467,1660,1943,2405,3367,12375,395,395,395,395,396,
396,396,398,397,399,399,401,401,403,403,405,406,408,409,411,413,
414,417,418,421,423,425,428,430,433,436,439,442,446,449,453,456,
461,464,469,474,479,483,489,495,501,506,514,520,528,535,543,552,
562,571,581,593,604,617,631,645,661,678,697,717,740,764,792,822,
856,895,939,990,1050,1123,1209,1319,1460,1653,1933,2394,3352,12324,390,390,
391,390,391,392,391,393,393,394,394,396,396,397,399,400,401,403,
404,405,407,410,410,413,415,417,420,422,424,427,430,432,436,439,
442,446,449,454,457,461,466,471,475,481,485,492,497,504,510,517,
524,532,540,549,558,567,578,589,601,614,627,641,658,674,693,714,
736,760,787,818,852,890,934,986,1045,1117,1203,1313,1453,1645,1925,2384,
3337,12273,386,385,386,386,386,387,387,388,388,389,390,391,391,393,
394,395,396,397,399,401,402,403,406,408,409,412,413,416,419,421,
424,426,430,432,436,439,442,447,450,454,458,463,467,472,478,482,
488,495,500,507,514,521,528,537,546,554,565,574,586,597,610,624,
638,654,671,689,710,732,756,783,814,847,886,930,980,1041,1111,1198,
1306,1447,1638,1916,2373,3323,12223,381,381,381,382,382,382,383,383,383,
385,385,386,387,388,389,390,391,393,394,395,397,399,400,403,404,
406,408,411,413,415,418,420,424,426,429,433,436,439,443,447,451,
455,460,464,469,474,480,485,491,497,504,511,518,525,534,542,551,
561,572,582,594,607,620,635,650,667,686,706,728,752,780,809,843,
882,925,976,1035,1107,1192,1300,1441,1630,1907,2363,3310,12173,377,376,377,
377,378,378,378,378,380,380,380,382,382,383,385,385,387,388,389,
390,392,394,395,397,399,401,403,405,408,409,412,415,418,420,423,
426,430,433,436,440,444,448,452,457,461,466,471,477,482,488,494,
501,507,515,522,531,539,548,558,568,579,591,604,616,632,646,664,
682,703,724,749,775,806,839,877,921,971,1030,1101,1187,1295,1434,1623,
1899,2353,3295,12125,372,373,372,373,373,374,374,374,375,375,377,377,
378,378,380,381,382,383,385,385,388,388,391,392,394,396,397,400,
402,404,407,409,412,414,417,421,423,426,430,434,437,441,445,449,
453,459,463,468,474,479,485,491,498,504,512,519,528,536,545,555,
565,576,587,600,614,628,643,661,678,699,721,745,771,802,835,873,
916,967,1025,1096,1182,1289,1427,1616,1891,2343,3282,12077,368,368,369,368,
369,370,369,370,371,371,372,373,373,375,375,376,378,378,380,382,
382,384,386,387,389,391,393,394,397,399,401,404,406,409,411,414,
417,421,423,427,431,434,438,442,447,450,456,460,465,471,476,482,
488,495,502,509,516,525,533,542,551,562,573,585,596,611,624,641,
657,675,695,717,741,768,798,831,869,912,962,1021,1091,1176,1283,1421,
1609,1883,2333,3269,12030,364,364,365,364,365,365,365,366,367,367,368,
368,369,370,371,372,373,375,375,377,378,379,381,383,384,386,388,
389,392,394,396,398,401,403,406,408,412,414,417,421,424,428,431,
436,439,443,448,453,457,463,467,474,479,486,491,499,506,514,521,
530,539,549,559,570,581,594,607,621,637,654,672,692,713,738,764,
794,827,865,907,958,1017,1086,1171,1277,1415,1602,1875,2324,3255,11984,360,
360,361,360,361,361,361,362,363,363,363,364,366,365,367,368,369,
370,371,372,373,375,377,378,379,381,383,385,387,389,391,393,395,
398,400,403,406,409,411,415,418,421,425,429,432,437,440,446,449,
455,460,465,470,477,482,489,496,503,511,519,527,536,546,556,567,
578,591,604,618,634,650,669,688,710,734,761,790,823,861,903,954,
1012,1081,1166,1272,1409,1595,1867,2315,3242,11938,356,356,357,356,357,357,
358,358,358,359,360,360,361,362,362,364,364,366,367,368,369,371,
371,374,375,376,379,380,382,384,386,388,390,393,395,397,400,403,
406,409,412,415,419,422,426,430,434,438,442,447,452,457,462,468,
474,480,486,493,501,508,516,524,533,543,553,564,575,588,601,615,
631,647,665,685,707,730,757,787,819,857,900,949,1007,1077,1161,1266,
1403,1589,1860,2304,3229,11894,352,353,352,353,353,353,354,354,354,355,
356,356,357,358,359,359,361,361,363,364,365,366,367,369,371,372,
374,375,377,380,381,383,385,388,390,392,395,397,401,403,406,409,
413,416,419,424,427,431,435,440,445,449,454,460,465,471,477,484,
490,498,505,513,522,530,540,551,561,572,585,598,612,627,644,662,
682,704,727,753,783,816,853,895,945,1003,1072,1156,1261,1397,1582,1853,
2295,3217,11849,349,348,349,349,349,350,350,350,350,352,351,353,353,
354,354,356,356,358,358,360,361,362,363,365,366,368,369,371,373,
374,377,378,381,382,385,387,390,392,395,398,401,403,407,410,413,
417,421,424,429,433,437,442,447,451,457,463,468,475,481,488,495,
502,510,519,528,537,548,558,569,582,595,609,625,641,659,678,700,
724,750,779,812,849,892,941,999,1067,1151,1256,1391,1576,1845,2286,3204,
11806,345,345,345,345,346,346,346,346,347,348,348,348,350,350,350,
352,353,353,355,355,357,358,359,361,362,363,365,367,368,370,372,
373,376,378,380,382,385,387,390,392,395,398,401,404,408,411,414,
418,422,426,431,434,440,444,449,455,460,465,472,479,485,492,500,
508,516,525,534,545,555,567,579,592,606,622,638,656,675,697,720,
747,776,808,846,887,937,995,1062,1147,1250,1386,1569,1838,2277,3192,11763,
341,342,341,342,342,342,342,343,344,343,345,345,345,347,347,347,
349,350,350,352,353,354,355,356,358,360,360,363,363,366,367,370,
371,373,375,378,379,383,384,387,390,393,395,399,402,404,409,412,
415,420,424,427,433,436,442,447,452,457,464,469,476,482,490,497,
505,514,522,532,542,553,564,576,589,603,619,635,653,672,694,717,
743,772,805,842,884,933,990,1058,1142,1246,1380,1563,1830,2269,3180,11720,
338,338,338,338,338,339,339,339,340,340,341,341,342,343,343,344,
345,346,347,347,349,350,352,352,354,355,357,358,359,362,363,365,
366,369,371,372,375,378,379,382,385,387,391,393,396,399,403,406,
409,413,417,422,425,430,434,439,444,450,455,461,467,473,480,487,
495,503,511,519,530,539,550,561,573,587,600,616,632,650,669,691,
714,740,768,802,838,880,929,986,1054,1137,1241,1374,1557,1823,2260,3168,
11679,334,335,334,335,335,335,336,335,337,336,337,338,339,339,339,
341,341,342,343,344,346,346,347,349,350,351,352,354,356,357,359,
360,363,364,366,368,371,372,375,377,380,382,385,388,391,393,397,
400,404,407,411,415,418,423,428,432,436,442,447,453,458,465,471,
477,485,492,500,509,517,527,536,547,559,571,583,598,613,629,647,
666,688,711,736,766,798,834,877,925,982,1050,1132,1236,1369,1551,1816,
2251,3157,11637,331,331,331,331,332,332,332,332,333,333,334,334,335,
336,336,337,337,339,339,341,341,343,343,345,346,347,349,350,352,
353,354,357,358,360,361,364,366,368,370,372,375,378,380,382,386,
388,391,395,398,401,405,408,413,416,421,425,429,435,439,445,450,
456,462,469,475,482,490,498,506,514,524,534,545,556,568,581,595,
610,626,644,664,684,708,733,763,794,831,873,922,977,1046,1128,1230,
1364,1545,1809,2244,3144,11597,328,327,328,328,328,329,329,329,329,330,
330,331,331,333,332,334,334,335,336,337,337,339,340,341,342,344,
345,346,347,350,350,352,354,356,357,360,361,364,365,368,370,373,
375,377,381,383,386,389,392,396,399,402,407,410,414,418,423,427,
432,438,442,448,454,459,466,473,480,487,496,503,512,522,531,542,
554,565,579,592,607,624,641,660,682,704,731,759,791,828,869,918,
974,1041,1123,1226,1359,1539,1802,2235,3133,11557
};
volatile uint8_t stopRequest = 0;
volatile bool quickStopping[NJ] = {false};
uint16_t quickSteps[NJ] = {0};
uint16_t quickIndex[NJ] = {0};
uint16_t quickDurationUnits[NJ] = {0};
uint32_t quickPrevious[NJ] = {0};

uint32_t nextQuickInterval(byte j) {
  uint16_t n = quickSteps[j];
  if (n == 1) return (uint32_t)quickDurationUnits[j] * 4UL;
  uint16_t index = n * (n - 1U) / 2U + quickIndex[j]++;
  uint16_t normalized = pgm_read_word(&stopCurve[index]);
  return (((uint32_t)quickDurationUnits[j] * normalized + 32768UL) >> 16) * 4UL;
}

// Executed in the ISR at the stop request, before another pulse.
// Use the current pulse interval to estimate speed; quantize travel DOWN to
// whole steps and never exceed the original target. At very low speed, less
// than one step of braking travel means no additional pulse is required.
void beginQuickStop(byte j) {
  byte m = PRIMARY[j];
  if (quickStopping[j] || !count[m]) return;
  uint32_t n = (QUICK_STOP_TICKS / 2UL) / periodTicks[j];
  if (n > count[m]) n = count[m];
  if (count[m] == moveSteps[j]) n = 0;
  count[m] = n;
  if (j == 1) count[2] = n;
  quickStopping[j] = true;
  if (!n) return;
  quickSteps[j] = (uint16_t)n;
  quickIndex[j] = 0;
  quickPrevious[j] = 0;
  quickDurationUnits[j] = (uint32_t)n * periodTicks[j] / 2UL;
  periodTicks[j] = nextQuickInterval(j);
  riseWait[j] = periodTicks[j];
}

inline void stepLevel(byte j, bool high) {
  switch (j) {
    case 0: if (high) PORTE |= _BV(4); else PORTE &= ~_BV(4); break;
    case 1:
      if (high) { PORTG |= _BV(5); PORTH |= _BV(3); }
      else { PORTG &= ~_BV(5); PORTH &= ~_BV(3); }
      break;
    case 2: if (high) PORTH |= _BV(5); else PORTH &= ~_BV(5); break;
    case 3: if (high) PORTB |= _BV(4); else PORTB &= ~_BV(4); break;
    case 4: if (high) PORTB |= _BV(6); else PORTB &= ~_BV(6); break;
  }
}

void armNextInterrupt() {
  uint32_t wait = 30000UL;
  for (byte j = 0; j < NJ; j++) {
    if (count[PRIMARY[j]] && riseWait[j] < wait) wait = riseWait[j];
    if (pulseHigh[j] && fallWait[j] < wait) wait = fallWait[j];
  }
  uint16_t now = TCNT1;
  uint16_t elapsed = (uint16_t)(now - timerReference);
  uint16_t gap = wait > (uint32_t)elapsed + 32UL ?
                 (uint16_t)(wait - elapsed) : 32U;
  OCR1A = now + gap;
}

// all step timing and counters are handled here, without Serial,
// floating point, or blocking waits. Timer0 remains available to Arduino.
ISR(TIMER1_COMPA_vect) {
  uint16_t now = TCNT1;
  uint16_t elapsed = (uint16_t)(now - timerReference);
  timerReference = now;
  bool any = false;
  for (byte j = 0; j < NJ; j++) {
    byte m = PRIMARY[j];
    // A newly requested brake starts from this timer reference.
    bool requested = (stopRequest & _BV(j)) != 0;
    if (requested) { stopRequest &= ~_BV(j); beginQuickStop(j); }
    uint32_t late = 0;
    bool due = false;
    if (count[m]) {
      if (riseWait[j] <= (requested ? 0 : elapsed)) { late = elapsed - riseWait[j]; due = true; riseWait[j] = 0; }
      else if (!requested) riseWait[j] -= elapsed;
    }
    lowWait[j] = lowWait[j] > elapsed ? lowWait[j] - elapsed : 0;
    bool fell = false;
    if (pulseHigh[j]) {
      if (fallWait[j] <= elapsed) {
        stepLevel(j, false);
        pulseHigh[j] = false;
        lowWait[j] = (uint16_t)(TCNT1 - timerReference) + STEP_LOW_US * 2UL;
        fell = true;
      } else fallWait[j] -= elapsed;
    }
    if (due) {
      // Never compress pulses to recover a serious timing overrun.
      // Finish any HIGH pulse normally, stop further steps, and report in loop.
      if (pulseHigh[j] || fell || lowWait[j] || late >= periodTicks[j] / 2UL) {
        timingFault = true;
        for (byte k = 0; k < NM; k++) count[k] = 0;
      } else {
        stepLevel(j, true);
        pulseHigh[j] = true;
        fallWait[j] = (uint16_t)(TCNT1 - timerReference) + STEP_HIGH_US * 2UL;
        position[m] += stepSign[m];
        count[m]--;
        if (j == 1) { position[2] += stepSign[2]; count[2]--; }
        // Use the next normal-ramp or quick-stop interval.
        if (count[m]) {
          periodTicks[j] = quickStopping[j] ? nextQuickInterval(j) :
              intervalForStep(j, moveSteps[j] - count[m] + 1UL);
          riseWait[j] = periodTicks[j] > late ? periodTicks[j] - late : 0;
        }
      }
    }
    if (count[m] || pulseHigh[j]) any = true;
  }
  if (timingFault) {
    any = false;
    for (byte j = 0; j < NJ; j++) if (pulseHigh[j]) any = true;
  }
  if (!any) {
    TIMSK1 &= ~_BV(OCIE1A);
    moving = false;
    motionFinished = true;
  } else armNextInterrupt();
}

// Initialize Timer1 without changing the existing pin wiring.
void setupMotionTimer() {
  ATOMIC_BLOCK(ATOMIC_RESTORESTATE) {
    TCCR1A = 0;
    TCCR1B = _BV(CS11);
    TIMSK1 = 0;
    TCNT1 = 0;
    TIFR1 = _BV(OCF1A);
  }
}

double pulsesPerDegree(byte m) {
  return PULSES_PER_REV[m] * GEAR[JOINT[m]] / 360.0;
}

double angle(byte j) {
  byte m = PRIMARY[j];
  // Copy the 32-bit counter atomically on the 8-bit AVR.
  long snapshot;
  ATOMIC_BLOCK(ATOMIC_RESTORESTATE) { snapshot = position[m]; }
  return (double)snapshot / pulsesPerDegree(m);
}

long rounded(double x) {
  return (long)(x >= 0 ? floor(x + 0.5) : ceil(x - 0.5));
}

char *spaces(char *p) {
  while (isspace((unsigned char)*p)) p++;
  return p;
}

bool number(char *p, double &value) {
  p = spaces(p);
  char *end;
  value = strtod(p, &end);

  return end != p &&
         isfinite(value) &&
         *spaces(end) == '\0';
}

// Accepts: 0,20,-15,30,10
// Also:   0 , 20 , -15 , 30 , 10
bool fiveAngles(char *p, double values[NJ]) {
  for (byte j = 0; j < NJ; j++) {
    p = spaces(p);

    char *end;
    values[j] = strtod(p, &end);

    if (end == p || !isfinite(values[j])) return false;

    end = spaces(end);

    if (j < NJ - 1) {
      if (*end != ',') return false;
      p = end + 1;
    } else {
      if (*end != '\0') return false;
    }
  }

  return true;
}

// -1 = ALL, -2 = invalid, 0..4 = joint.
int scope(char *p) {
  p = spaces(p);

  if (*p == '\0') return -1;

  if (strncmp(p, "ALL", 3) == 0 &&
      *spaces(p + 3) == '\0') {
    return -1;
  }

  double value;
  if (!number(p, value) ||
      value < 1 || value > NJ ||
      floor(value) != value) {
    return -2;
  }

  return (int)value - 1;
}

// S requests a nonblocking quick ramp. Y disables immediately,
// cancels pending steps, and clears home; it never waits for a braking ramp.
void stopMotors(int joint, bool disable) {
  ATOMIC_BLOCK(ATOMIC_RESTORESTATE) {
    for (byte j = 0; j < NJ; j++) {
      if (joint >= 0 && j != joint) continue;
      if (disable) {
        for (byte m = 0; m < NM; m++) if (JOINT[m] == j) {
          digitalWrite(EN_PIN[m], DISABLE);
          count[m] = 0;
        }
        stepLevel(j, false);
        pulseHigh[j] = false;
        quickStopping[j] = false;
        stopRequest &= ~_BV(j);
        homed[j] = false;
      } else if (count[PRIMARY[j]] && !quickStopping[j]) stopRequest |= _BV(j);
    }
    bool any = false;
    for (byte j = 0; j < NJ; j++) if (count[PRIMARY[j]] || pulseHigh[j]) any = true;
    moving = any;
    if (!any) { TIMSK1 &= ~_BV(OCIE1A); motionFinished = false; }
    else if (stopRequest) {
      // Service S promptly even during a slow, long pulse interval.
      OCR1A = TCNT1 + 64U;
      TIFR1 = _BV(OCF1A);
      TIMSK1 |= _BV(OCIE1A);
    }
  }
}

bool validSpeed(byte j, double value) {
  byte m = PRIMARY[j];
  double hz = value * pulsesPerDegree(m);
  // Compare in degrees/sec to avoid rejecting the exact limit because
  // pulsesPerDegree() is rounded on the Mega's 32-bit floating point.
  double maximumDps = MAX_STEP_HZ * 360.0 /
                      (PULSES_PER_REV[m] * GEAR[j]);
  
  // Limit joint speed as well as the driver pulse rate.
  if (maximumDps > MAX_JOINT_DPS) maximumDps = MAX_JOINT_DPS;
  if (!isfinite(value) || value <= 0 || !isfinite(hz) ||
      value > maximumDps || hz < 1000000.0 / 2000000000.0) {
    Serial.print(F("Invalid speed for J"));
    Serial.print(j + 1);
    Serial.print(F("; maximum deg/s: "));
    Serial.println(maximumDps, 3);
    return false;
  }
  return true;
}

void setHome(int joint) {
  if (moving) {
    Serial.println(F("Stop before setting home."));
    return;
  }

  for (byte m = 0; m < NM; m++) {
    if (joint >= 0 && JOINT[m] != joint) continue;

    position[m] = 0;
    homed[JOINT[m]] = true;
    digitalWrite(EN_PIN[m], ENABLE);
  }

  delayMicroseconds(1000);
  Serial.println(F("Current position saved as zero/home."));
}

// All inputs here are ABSOLUTE JOINT angles.
// Gear ratios and driver pulse settings are applied per motor.
void moveTo(const double target[NJ], const bool active[NJ]) {
  if (!configOK) {
    Serial.println(F("Invalid configuration."));
    return;
  }

  if (moving) {
    Serial.println(F("Busy. Wait for Done or send S."));
    return;
  }

  long delta[NM] = {0};
  unsigned long largest = 0;
  unsigned long newPeriod[NJ] = {0};

  // Validate every selected joint before moving anything.
  for (byte j = 0; j < NJ; j++) {
    if (!active[j]) continue;

    if (!validSpeed(j, speedDps[j])) return;
    // Compute Hz before reciprocal to avoid rounding 500 us up to 501 us.
    double stepHz = (speedDps[j] * PULSES_PER_REV[PRIMARY[j]] * GEAR[j]) / 360.0;
    newPeriod[j] = (unsigned long)ceil(1000000.0 / stepHz);

    if (!homed[j]) {
      Serial.print(F("Set home first for J"));
      Serial.println(j + 1);
      return;
    }

    if (!isfinite(target[j])) {
      Serial.println(F("Invalid angle."));
      return;
    }

    // Half-pulse tolerance: angle() is quantised to whole pulses, so a relative
    // move from e.g. 80.01 deg by +10 must not be rejected for landing on 90.01.
    double tol = 0.5 / pulsesPerDegree(PRIMARY[j]);
    if (LIMITED[j] &&
        (target[j] < MIN_DEG[j] - tol || target[j] > MAX_DEG[j] + tol)) {
      Serial.print(F("Rejected: J"));
      Serial.print(j + 1);
      Serial.print(F(" range is "));
      Serial.print(MIN_DEG[j], 0);
      Serial.print(F(" to "));
      Serial.println(MAX_DEG[j], 0);
      return;
    }
  }

  for (byte m = 0; m < NM; m++) {
    byte j = JOINT[m];
    if (!active[j]) continue;

    double scale = pulsesPerDegree(m);
    double exact = target[j] * scale;

    if (!isfinite(exact) ||
        fabs(exact) > MAX_POSITION_PULSES) {
      Serial.println(F("Target exceeds counter range."));
      return;
    }

    long endpoint = rounded(exact);

    // Rounding must not put an endpoint outside its limit.
    if (LIMITED[j]) {
      long minimum = (long)ceil(MIN_DEG[j] * scale - 0.01);
      long maximum = (long)floor(MAX_DEG[j] * scale + 0.01);

      if (endpoint < minimum) endpoint = minimum;
      if (endpoint > maximum) endpoint = maximum;
    }

    long difference = endpoint - position[m];   // integer math, exact

    if (labs(difference) > MAX_MOVE_PULSES) {
      Serial.println(F("Move exceeds pulse limit."));
      return;
    }

    delta[m] = difference;

    unsigned long magnitude = (unsigned long)labs(delta[m]);
    if (magnitude > largest) largest = magnitude;
  }

  if (largest == 0) {
    Serial.println(F("Already at target."));
    positionReportPending = true;
    return;
  }

  // Prepare every normal profile before enabling any motor.
  if (!prepareRamps(delta)) return;
  stopRequest = 0;
  for (byte j = 0; j < NJ; j++) {
    quickStopping[j] = false;
    periodUs[j] = newPeriod[j];
    // Schedule acceleration from rest, including the first pulse.
    periodTicks[j] = moveSteps[j] ? intervalForStep(j, 1) : 0;
    riseWait[j] = periodTicks[j];
    lowWait[j] = 0;
    pulseHigh[j] = false;
  }

  for (byte m = 0; m < NM; m++) {
    count[m] = (unsigned long)labs(delta[m]);
    stepSign[m] = delta[m] >= 0 ? 1 : -1;

    digitalWrite(STEP_PIN[m], LOW);

    if (!count[m]) continue;

    bool direction = delta[m] > 0 ? POS_DIR[m] : !POS_DIR[m];
    digitalWrite(DIR_PIN[m], direction ? HIGH : LOW);
    digitalWrite(EN_PIN[m], ENABLE);
  }

  delayMicroseconds(1000);
  ATOMIC_BLOCK(ATOMIC_RESTORESTATE) {
    motionFinished = false;
    timingFault = false;
    moving = true;
    timerReference = TCNT1;
    armNextInterrupt();
    TIFR1 = _BV(OCF1A);
    TIMSK1 |= _BV(OCIE1A);
  }
}

// Loop only reports completion; Timer1 generates the pulses.
void updateMotion() {
  bool finished;
  ATOMIC_BLOCK(ATOMIC_RESTORESTATE) {
    finished = motionFinished;
    motionFinished = false;
  }
  if (finished) {
    if (timingFault) Serial.println(F("Timing overrun: motion stopped; check interrupt load."));
    else Serial.println(F("Done."));
    positionReportPending = true;
  }
}

void printPositions() {
  for (byte j = 0; j < NJ; j++) {
    Serial.print(F("J"));
    Serial.print(j + 1);
    Serial.print(F(": "));
    Serial.print(angle(j), 3);
    Serial.print(F(" degrees; home "));
    Serial.print(homed[j] ? F("SET") : F("UNSET"));
    Serial.print(F("; speed deg/s: "));
    Serial.println(speedDps[j], 3);
  }
}

void help() {
  Serial.println(F("115200 baud; Newline"));
  Serial.println(F("All joints default to 10 deg/s; maximum 22.5 deg/s."));
  // Clarify short moves and immediate disable behavior.
  Serial.println(F("Short moves use a lower peak speed. Confirmed D disables without a ramp."));
  Serial.println(F("F5 : set selected joint speed to 5 deg/s"));
  Serial.println(F("R5,10,3,20,8 : set J1..J5 speeds in deg/s"));
  Serial.println(F("Set speeds while stopped, then send G, A, M or B."));
  Serial.println(F("Speeds persist; normal accel/decel 0.5 s, quick stop up to 0.1 s."));
  Serial.println(F("H       : set ALL current positions as zero/home"));
  Serial.println(F("H2      : set J2 current position as zero/home"));
  Serial.println(F("M0,20,-15,30,10 : absolute angles for J1..J5"));
  Serial.println(F("Spaces around commas are allowed."));
  Serial.println(F("M0,0,0,0,0 : return ALL joints to zero/home"));
  Serial.println(F("B / B2  : return ALL / J2 home"));
  Serial.println(F("J2      : select J2; selection supports J1..J5"));
  Serial.println(F("A10     : selected joint +10 relative degrees"));
  Serial.println(F("A-10    : selected joint -10 relative degrees"));
  Serial.println(F("G30     : selected joint to absolute 30 degrees"));
  Serial.println(F("S / S2  : quick ramp stop ALL / J2; retain holding"));
  Serial.println(F("D / D2  : request disable ALL / J2; confirm Y or cancel N"));
  Serial.println(F("Pending D: movement continues; S stops and cancels the request."));
  Serial.println(F("Positions print automatically when all movement stops."));
  Serial.println(F("V       : positions"));
  Serial.println(F("?       : help"));
}

void command(char *p) {
  p = spaces(p);
  if (!*p) return;

  for (char *q = p; *q; q++) {
    *q = toupper((unsigned char)*q);
  }

  char action = *p;
  char *args = spaces(p + 1);

  // Confirmation uses a complete line, just like the other commands.
  if (pendingDisable != -2 && action != 'S') {
    if (*args || (action != 'Y' && action != 'N')) {
      Serial.println(F("Disable pending: enter Y or N; S remains available."));
      return;
    }
    int joint = pendingDisable;
    pendingDisable = -2;
    if (action == 'N') {
      Serial.println(F("Disable cancelled."));
      return;
    }
    stopMotors(joint, true);
    Serial.println(F("Disabled immediately; set home again before moving."));
    positionReportPending = true;
    return;
  }
  if (action == 'Y' || action == 'N') {
    Serial.println(F("No disable confirmation pending."));
    return;
  }

  if (action == 'S' || action == 'D' ||
      action == 'H' || action == 'B') {
    int joint = scope(args);

    if (joint == -2) {
      Serial.println(F("Use joint 1..5, ALL, or no argument."));
      return;
    }

    if (action == 'D') {
      pendingDisable = joint;
      Serial.print(F("Disable "));
      if (joint < 0) Serial.print(F("ALL joints"));
      else {
        Serial.print(F("J"));
        Serial.print(joint + 1);
      }
      Serial.println(F("? Holding torque will be removed. Y/N"));
      return;
    }
    if (action == 'S') {
      if (pendingDisable != -2) {
        pendingDisable = -2;
        Serial.println(F("Disable cancelled."));
      }
      stopMotors(joint, false);
      // S returns while the selected joints are still braking.
      Serial.println(F("Quick stop requested; wait for Done."));
      positionReportPending = true;
      return;
    }

    if (action == 'H') {
      setHome(joint);
      return;
    }

    double target[NJ] = {0};
    bool active[NJ] = {false};

    for (byte j = 0; j < NJ; j++) {
      active[j] = joint < 0 || j == joint;
    }

    moveTo(target, active);
    return;
  }

  if (moving) {
    Serial.println(F("Busy. Wait for Done or send S."));
    return;
  }

  if (action == 'F') {
    double value;
    if (!number(args, value)) {
      Serial.println(F("Format: F5 (positive degrees/second)"));
      return;
    }
    if (!validSpeed(selected, value)) return;
    speedDps[selected] = value;
    Serial.println(F("Speed saved."));
    return;
  }

  if (action == 'R') {
    double values[NJ];
    if (!fiveAngles(args, values)) {
      Serial.println(F("Format: R5,10,3,20,8 (degrees/second)"));
      return;
    }
    for (byte j = 0; j < NJ; j++) {
      if (!validSpeed(j, values[j])) return;
    }
    for (byte j = 0; j < NJ; j++) speedDps[j] = values[j];
    Serial.println(F("Speeds saved."));
    return;
  }

  if (action == 'M') {
    double target[NJ];
    bool active[NJ] = {true, true, true, true, true};

    if (!fiveAngles(args, target)) {
      Serial.println(F("Format: M0 , 20 , -15 , 30 , 10"));
      return;
    }

    moveTo(target, active);
    return;
  }

  if (action == 'J') {
    int joint = scope(args);

    if (joint < 0) {
      Serial.println(F("Use J1 through J5."));
      return;
    }

    selected = (byte)joint;
    Serial.print(F("Selected J"));
    Serial.println(selected + 1);
    return;
  }

  if (action == 'A' || action == 'G') {
    double value;

    if (!number(args, value)) {
      Serial.println(F("Invalid angle."));
      return;
    }

    double target[NJ] = {0};
    bool active[NJ] = {false};

    active[selected] = true;
    target[selected] = action == 'A'
      ? angle(selected) + value
      : value;

    moveTo(target, active);
    return;
  }

  if (*args) {
    Serial.println(F("Unexpected arguments."));
    return;
  }

  if (action == 'V') printPositions();
  else if (action == '?') help();
  else Serial.println(F("Unknown command. Send ?."));
}

void readSerial() {
  byte budget = 16;

  while (budget-- && Serial.available()) {
    updateMotion();

    char c = (char)Serial.read();

    if (c == '\r' || c == '\n') {
      if (overflowed) {
        Serial.println(F("Command too long; discarded."));
      } else if (bufferLength) {
        buffer[bufferLength] = '\0';
        command(buffer);
      }

      bufferLength = 0;
      overflowed = false;
    } else if (!overflowed) {
      if (bufferLength < sizeof(buffer) - 1) {
        buffer[bufferLength++] = c;
      } else {
        overflowed = true;
      }
    }
  }
}

void setup() {
  Serial.begin(115200);

  for (byte m = 0; m < NM; m++) {
    digitalWrite(EN_PIN[m], DISABLE);
    pinMode(EN_PIN[m], OUTPUT);

    digitalWrite(STEP_PIN[m], LOW);
    pinMode(STEP_PIN[m], OUTPUT);

    digitalWrite(DIR_PIN[m], LOW);
    pinMode(DIR_PIN[m], OUTPUT);
  }

  // Reserve Timer1 for the motion scheduler.
  setupMotionTimer();
  configOK = true;

  for (byte m = 0; m < NM; m++) {
    double scale = pulsesPerDegree(m);

    if (!isfinite(scale) || scale <= 0 ||
        PULSES_PER_REV[m] <= 0 || GEAR[JOINT[m]] <= 0) {
      configOK = false;
    }
  }

  for (byte m = 0; m < NM; m++) {
    if (fabs(pulsesPerDegree(m) -
             pulsesPerDegree(PRIMARY[JOINT[m]])) > 0.00001) configOK = false;
  }

  help();
  Serial.println(F("Place arm at physical zero, then send H."));

  if (!configOK) {
    Serial.println(F("ERROR: Invalid motor configuration."));
  }
}

void loop() {
  updateMotion();
  readSerial();
  // Report final positions once all timer-controlled motion stops.
  if (positionReportPending && !moving) {
    positionReportPending = false;
    printPositions();
  }
}